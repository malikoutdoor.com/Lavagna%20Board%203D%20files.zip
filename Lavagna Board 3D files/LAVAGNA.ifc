Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T15:23:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 15:23:55 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{9BA66654-F924-44EF-8BFB-322A4B55E7A8}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 15:23:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 15:23:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 15:23:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0BTAR004 - HTC 3, Gioco LAVAGNA:0BTAR004 - HTC 3:196029
In: 0 - Piano Terra
Type - Material: HTC 3
Type - Altro - Categoria: Modelli generici; Nome famiglia: Gioco LAVAGNA
Type - Dati identità - BIM Name: LAVAGNA; BIM Object Type: GIOCHI - GAMES; Code: 0BTAR004; Designer: MASSIMO TASCA; Family Name: LAVAGNA; Nome del tipo: 0BTAR004 - HTC 3; URL Eng: https://www.bellitalia.net/en/products/games/lavagna/; URL Ita: https://www.bellitalia.net/prodotti/giochi/lavagna/
Type - Dimensioni - Dimensions: 2100 mm X 700 mm X 1600 mm + 350 mm
Type - Generale - Accessori: Supplemento per piastra di fissaggio in calcestruzzo; Accessories: Supplement for concrete fixing plate; Descrizione Tecnica Famiglia: Il gioco LAVAGNA è costituito da un corpo monolitico a sezione rastremata, con base di 175 mm. Il corpo principale è collegato a terra con un basamento che ne garantisce perfetta stabilità.; Descrizione Tecnica per Codice: LAVAGNA IN HTC 3 - ANTRACITE LISCIO CASSERO NON VERNICIATA; Fissaggio: Plinto di fondazione; Fixings: Foundation plinth; Technical Description Family: The LAVAGNA game consists of a monolithic body with a tapered section, with a 175 mm base. The main body is connected to the ground with a base which guarantees perfect stability.; Technical Description for Article: BOARD IN HTC3 - CHARCOAL GREY SMOOTH FORMWORK WITHOUT VARNISH
Type - Materiali e finiture - MATERIALE LAVAGNA: HTC 3; Materiale Principale: HTC 3; Materiale Secondario: HTC 3; Primary Material: HTC 3; Secondary Material: HTC 3
Type - Meccanica - Weight ( kg): 1411 Kg
Pset_BuildingElementProxyCommon - Reference: 0BTAR004 - HTC 3
Altro - Famiglia: Gioco LAVAGNA: 0BTAR004 - HTC 3; Famiglia e tipo: Gioco LAVAGNA: 0BTAR004 - HTC 3; ID tipo: Gioco LAVAGNA: 0BTAR004 - HTC 3; Tipo: Gioco LAVAGNA: 0BTAR004 - HTC 3
Dimensioni - Area: 5.22023 m2; Volume: 0.607599 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
